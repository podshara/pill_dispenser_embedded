# IAR project pill_dispenser.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.1.4.178; C:\ti\TivaWare_C_Series-2.1.4.178\inc; C:\TI-CMSIS-Devices-8636\TI\LM4F\Include; C:\ti\TivaWare_C_Series-2.1.4.178\driverlib\rvmdk; C:\Users\varit\Desktop\WI19\CSE474\pill_dispenser_embedded; C:\Users\varit\Desktop\WI19\CSE474\pill_dispenser_embedded\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup_M.c LCD_display.c main.c pillslot.c pillslot.h PLL.c schedule.c schedule.h servo.c servo.h servoTest.c SSD2119.c startup.s
  group driverlib
    driverlib/: gpio.c interrupt.c sysctl.c systick.c timer.c uart.c udma.c
