<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pill_dispenser.ewp</path>
    </project>
    <batchBuild />
</workspace>
